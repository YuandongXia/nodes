<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\WM-IOT-LoRaWAN-node-STM32L072.ewp</path>
    </project>
    <batchBuild />
</workspace>
