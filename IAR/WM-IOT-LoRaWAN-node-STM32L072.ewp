# IAR project WM-IOT-LoRaWAN-node-STM32L072.ewp, settings and files
configuration LoRaMac_EU868_Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073CZ ST STM32L073CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; USE_DEBUGGER; REGION_CN470; DEBUG_EN
  ICCARM.CCIncludePath2: ..\src\Apps; ..\src\Driver\Boards\Inc; ..\src\Driver\CMSIS\Inc; ..\src\Driver\Radio\Inc; ..\src\Driver\STM32L0xx_HAL_Driver\Inc; ..\src\LoRaMac\Crypto\Inc; ..\src\LoRaMac\Mac\Inc; ..\src\LoRaMac\Region\Inc; ..\src\LoRaMac\Utilities\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WM-IOT-LoRaWAN-node-STM32L072.bin
  ILINK.IlinkOutputFile: WM-IOT-LoRaWAN-node-STM32L072.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Apps
    ../src/Apps/: callback.c main.c
    ../: readme.md
  group Driver/Boards
    ../src/Driver/Boards/Src/: adc-board.c adc.c board.c delay.c fifo.c gpio-board.c gpio.c rtc-board.c spi-board.c sx1276-board.c timer.c uart-board.c uart.c
  group Driver/CMSIS
    ../src/Driver/CMSIS/Src/: system_stm32l0xx.c
  group Driver/Radio
    ../src/Driver/Radio/Src/: sx1276.c
  group Driver/Startup
    ../src/Driver/Startup/: startup_stm32l072xx.s startup_stm32l073xx.s
  group Driver/STM32L0xx_HAL_Driver
    ../src/Driver/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
  group LoRaMac/Crypto
    ../src/LoRaMac/Crypto/Src/: aes.c cmac.c
  group LoRaMac/Mac
    ../src/LoRaMac/Mac/Src/: LoRaMac.c LoRaMacCrypto.c
  group LoRaMac/Region
    ../src/LoRaMac/Region/Src/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group LoRaMac/Utilities
    ../src/LoRaMac/Utilities/Src/: sysIrqHandlers.c utilities.c
